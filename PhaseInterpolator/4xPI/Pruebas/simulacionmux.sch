v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {/foss/designs/Propio/MUXdosAuno.sym} 90 -40 0 0 {name=x1}
C {netlist_not_shown.sym} -350 -170 0 0 {name=s1 only_toplevel=false value=blabla}
C {vsource.sym} 110 -90 0 0 {name=VDD value=1.2 savecurrent=false}
C {vsource.sym} 170 -90 0 0 {name=V2 value=3 savecurrent=false}
C {vsource.sym} 220 -90 0 0 {name=V3 value="PULSE(0 1.2 0.0 1p 1p \{Tclk/4\} \{Tclk/2\})" savecurrent=false}
C {vsource.sym} 270 -90 0 0 {name=V4 value=3 savecurrent=false}

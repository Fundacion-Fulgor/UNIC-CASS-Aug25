v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {sg13g2_stdcells/sg13g2_dfrbp_1.sym} 110 -60 0 0 {name=x1 VDD=VDD VSS=VSS prefix=sg13g2_ }

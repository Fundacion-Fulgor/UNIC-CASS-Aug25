v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {gnd.sym} 5.693779904306226 -14.96242950393791 0 0 {name=l1 lab=GND}
C {lab_wire.sym} 60 -80 0 0 {name=p1 sig_type=std_logic lab=xxx}

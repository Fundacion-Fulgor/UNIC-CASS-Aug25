v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {TEXTO DE EJEMPLO} -70 -30 0 0 0.4 0.4 {}
